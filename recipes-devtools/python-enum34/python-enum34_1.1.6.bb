inherit setuptools
require python-enum34.inc
