IMAGE_INSTALL_append = "opencv libgomp python-pip python-matplotlib python-pyqt inotify-tools gdb ueye-drivers ueye-drivers-dev ueye-drivers-service python-pyueye"
IMAGE_INSTALL_remove = "qt4-demos qt4-examples"

